# Keil uVision project Project.uvprojx, settings and files
target HY-MiniSTM32V (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\USER;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER\App;..\..\..\Libraries\uC-CPU;..\..\..\Libraries\uC-LIB;..\..\..\Libraries\uCOS-II;..\..\..\Libraries\GLCD;..\..\..\Libraries\TouchPanel;..\..\..\Libraries\;..\..\..\Libraries\uCGUI_LIB\USER;..\..\..\Libraries\uCGUI_LIB\USER\uCGUI\AntiAlias;..\..\..\Libraries\uCGUI_LIB\USER\uCGUI\Config;..\..\..\Libraries\uCGUI_LIB\USER\uCGUI\ConvertColor;..\..\..\Libraries\uCGUI_LIB\USER\uCGUI\ConvertMono;..\..\..\Libraries\uCGUI_LIB\USER\uCGUI\Core;..\..\..\Libraries\uCGUI_LIB\USER\uCGUI\Font;..\..\..\Libraries\uCGUI_LIB\USER\uCGUI\GUIDemo;..\..\..\Libraries\uCGUI_LIB\USER\uCGUI\GUIDemo2;..\..\..\Libraries\uCGUI_LIB\USER\uCGUI\JPEG;..\..\..\Libraries\uCGUI_LIB\USER\uCGUI\MemDev;..\..\..\Libraries\uCGUI_LIB\USER\uCGUI\MultiLayer;..\..\..\Libraries\uCGUI_LIB\USER\uCGUI\Widget;..\..\..\Libraries\uCGUI_LIB\USER\uCGUI\WM;..\..\..\Libraries\jdksmidi\include\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../USER/App/: app_cfg.h includes.h EK_config.h main.cpp tasks.cpp
  group GUI
    ../USER/App/gui/: ChordFileWindowDLG.c ChordFileWindow.cpp ChordFileChooserWindowDLG.c ChordFileChooserWindow.cpp
    ../USER/App/gui/img/: pause.c play.c stop.c close.c busy.c open.c
  group User
    ../USER/: stm32f10x_conf.h os_cfg.h stm32f10x_it.cpp OS_AppHooks.cpp startup_stm32f10x_hd.s
  group EK
    ../../../Libraries/EK/: EK_config.cpp EK_usart.cpp EK_gui.cpp EK_gpio.cpp EK_sd.cpp EK_retarget.c EK_retarget.cpp EK_tasks.cpp
    ../../../Libraries/EK/midi/: EK_key.cpp EK_midi.cpp EK_note.cpp EK_chordstyle.cpp EK_chordfile.cpp
  group TouchPanel
    ../../../Libraries/TouchPanel/: TouchPanel.c
  group CMSIS
    ../USER/: system_stm32f10x.c
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ucGUI
    ../../../Libraries/uCGUI_LIB/: uCGUI.lib
    ../../../Libraries/uCGUI_LIB/USER/uCGUI/GUIDemo/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_Bitmap.c GUIDEMO_Bitmap4bpp.c GUIDEMO_Circle.c GUIDEMO_ColorBar.c GUIDEMO_ColorList.c GUIDEMO_Cursor.c GUIDEMO_Dialog.c GUIDEMO_Font.c GUIDEMO_FrameWin.c GUIDEMO_Graph.c GUIDEMO_HardwareInfo.c GUIDEMO_Intro.c GUIDEMO_LUT.c GUIDEMO_MemDevB.c GUIDEMO_Messagebox.c GUIDEMO_Navi.c GUIDEMO_Polygon.c GUIDEMO_ProgBar.c GUIDEMO_Speed.c GUIDEMO_Touch.c GUIDEMO_WM.c MainTask.c MicriumLogo.c MicriumLogoWRed.c
    ../../../Libraries/uCGUI_LIB/USER/uCGUI/Config/: GUIConf.h GUITouchConf.h LCDConf.h
    ../../../Libraries/uCGUI_LIB/USER/: GUI_X_uCOS.c GUI_X_Touch.c
  group GLCD
    ../../../Libraries/GLCD/: AsciiLib.c GLCD.c GLCD_UCGUI.c HzLib.c
  group uc-CPU
    ../../../Libraries/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group uc-LIB
    ../../../Libraries/uC-LIB/: lib_mem.c lib_str.c
    ../../../Libraries/uC-LIB/Ports/RealView/: lib_mem_a.asm
  group uCOS-II
    ../../../Libraries/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../../../Libraries/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group SD_Card
    ../../../Libraries/SD_Card/: sdio_sd.c
  group FATFS
    ../../../Libraries/FATFS/src/: diskio.c ff.c
  group jdksmidi
    ../../../Libraries/jdksmidi/src/: jdksmidi_advancedsequencer.cpp jdksmidi_driver.cpp jdksmidi_driverdump.cpp jdksmidi_edittrack.cpp jdksmidi_file.cpp jdksmidi_fileread.cpp jdksmidi_filereadmultitrack.cpp jdksmidi_fileshow.cpp jdksmidi_filewrite.cpp jdksmidi_filewritemultitrack.cpp jdksmidi_keysig.cpp jdksmidi_manager.cpp jdksmidi_matrix.cpp jdksmidi_midi.cpp jdksmidi_msg.cpp jdksmidi_multitrack.cpp jdksmidi_parser.cpp jdksmidi_process.cpp jdksmidi_queue.cpp jdksmidi_sequencer.cpp jdksmidi_showcontrol.cpp jdksmidi_showcontrolhandler.cpp jdksmidi_smpte.cpp jdksmidi_sysex.cpp jdksmidi_tempo.cpp jdksmidi_tick.cpp jdksmidi_track.cpp jdksmidi_utils.cpp
